# Keil uVision project LabVIEW.uvproj, settings and files
target LabVIEW (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LabVIEW
  c flags: Optim=3 OneElfS=1
  c misc: --loose_implicit_cast
  c include: ..\Include;..\..\..\..\..\..\..\..\CCodeGen\include\blockdiagram;..\..\..\..\..\..\..\..\CCodeGen\include\comms;..\System
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Target Startup
    ../System/: startup_stm32f10x_hd.s main.c system_stm32f10x.c
  group Target Drivers
    ../Drivers/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
