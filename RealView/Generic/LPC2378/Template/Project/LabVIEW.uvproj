# Keil uVision project LabVIEW.uvproj, settings and files
target LabVIEW (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LabVIEW
  c flags: Optim=1
  c misc: --loose_implicit_cast
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x7fe00000 size 0x4000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fd00000 size 0x2000
  group Target Startup
    ../System/: LPC2300.s RTX_Config.c File_Config.c TargetInit.c
  group Target Drivers
    ../Drivers/Ethernet/: LPC23_EMAC.c
    ../Drivers/Serial/: ARM_Serial.c
    ../Drivers/RTClock/: ARM_RTClock.c
    ../Drivers/Interrupt/: ARM_irq.c
    ../Drivers/I2C/: ARM_I2C.c
    ../Drivers/SPI/: ARM_SPI.c
    ../Drivers/FlashFS/: MCI_LPC23xx.c FS_ARM_L.lib
    ../Drivers/CAN/: CAN_LPC2378.lib RLARM_CAN.lib
    ../Drivers/Peripheral Power/: ARM_Periph_Power.c
    ../Drivers/Profiling/: profile_timer.c
    ../Drivers/TCP/: TCP_ARM_L.lib
    ../Drivers/IO/: MCB2300IO.lib
