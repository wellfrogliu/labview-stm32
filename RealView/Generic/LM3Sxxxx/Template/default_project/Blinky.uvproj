# Keil uVision project Blinky.uvproj, settings and files
target LM3S8962 Flash (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c misc: --diag_suppress 3419
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: Startup.s
  group Source Code
    ./: Blinky.c
