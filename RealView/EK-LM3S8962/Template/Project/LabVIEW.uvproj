# Keil uVision project LabVIEW.uvproj, settings and files
target LabVIEW (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LabVIEW
  c flags: Optim=3
  c define: OS_CLOCK=50000000
  c misc: --loose_implicit_cast
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Target Startup
    ../System/: Startup.s RTX_Config.c File_Config.c Retarget.c TargetInit.c
  group Target Drivers
    ../Drivers/Interrupt/: ARM_irq.c
    ../Drivers/RTClock/: ARM_RTClock.c
    ../Drivers/Serial/: ARM_Serial.c
    ../Drivers/Display/: EKLM3S8962_Display.c
    ../Drivers/Ethernet/: LM3S_EMAC.c
    ../Drivers/I2C/: ARM_I2C.c
    ../Drivers/SPI/: ARM_SPI.c
    ../Drivers/Pins/: LM3S_Pins.c
    ../Drivers/FlashFS/: SPI_LM3S8962.c FS_CM3.lib
    ../Drivers/CAN/: CAN_EK-LM3S8962.lib RLARM_CAN.lib
    ../Drivers/Peripheral Power/: ARM_Periph_Power.c
    ../Drivers/Profiling/: profile_timer.c
    ../Drivers/TCP/: TCP_CM3.lib
    ../Drivers/IO/: EKLM3S8962_io.lib LM3Sxxxx_IO.lib
